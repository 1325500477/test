# Keil uVision project EMP6910.uvproj, settings and files
target EMP6910 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EMP6910 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\User\UserCode;..\..\User\BSP;..\..\User\BSP\Stm32f10x;..\..\User\UserCode\Process
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT6: RAM 0x68000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group stm32_lib
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dbgmcu.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_iwdg.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_pwr.h
  group BSP
    ../../User/BSP/: BspConfig.c bsp.h
    ../../User/BSP/Communicate/: communicate.c
    ../../User/BSP/Ethernet/: enc28j60.c ethernet.c ip_arp_udp_tcp.c spi.c
    ../../User/BSP/Serial/: serial.c
    ../../User/BSP/OpCtrl/: OpCtrl.c
    ../../User/BSP/Command/: bsp_command.c
    ../../User/BSP/StepMotor/: StepMotor.c
    ../../User/BSP/Test/: Test.c
    ../../User/BSP/EEPROM/: eeprom.c eeprom_par.c
    ../../User/BSP/Stm32f10x/: stm32f10x_it.c system_stm32f10x.c
    ../../User/BSP/Driver/: driver.c hardware.c my_fun.c
  group UserCode
    ../../User/: main.c
    ../../User/UserCode/Command/: command.c
    ../../User/UserCode/Parameter/: parameter.c
    ../../User/UserCode/Process/: process.c
    ../../User/UserCode/: IOCfg.h Speed.h
